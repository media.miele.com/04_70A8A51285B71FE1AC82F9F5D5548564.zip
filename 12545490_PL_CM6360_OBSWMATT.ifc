Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 08b8f9b3-0d0f-44fe-b61f-f2dae0d5d946, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-07T13:34:52+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12545490_PL_CM6360_OBSWMATT:29636021_PL_12545490_CM6360_OBSWMATT, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, <Unnamed>, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_CLST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 251 mm; Height: 359 mm; Depth: 427 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 29636021_PL_12545490_CM6360_OBSWMATT; sets with these values: 2
